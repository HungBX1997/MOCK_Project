# IAR project MOCK_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\source; ..\CMSIS\Include; ..\MKL46Z; ..\driver\gpio\Driver_gpio; ..\driver\gpio\HAL_gpio; ..\driver\i2c\Driver_i2c; ..\driver\i2c\HAL_i2c; ..\driver\port\HAL_port; ..\driver\lcd_1602; ..\driver\tea5767; ..\driver\clock; ..\driver\keyboard; ..\driver\core\Driver_core; ..\device; ..\device\stateMachine
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MOCK_Project.srec
  ILINK.IlinkOutputFile: MOCK_Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group device
    ../device/: board.h
  group device/stateMachine
    ../device/stateMachine/: stateMachine.c stateMachine.h
  group driver/clock
    ../driver/clock/: clock.c clock.h
  group driver/core
    ../driver/core/Driver_core/: DRIVER_core.c DRIVER_core.h
  group driver/gpio/Driver_gpio
    ../driver/gpio/Driver_gpio/: DRIVER_gpio.c DRIVER_gpio.h
  group driver/gpio/HAL_gpio
    ../driver/gpio/HAL_gpio/: HAL_gpio.c HAL_gpio.h
  group driver/i2c/Driver_i2c
    ../driver/i2c/Driver_i2c/: DRIVER_i2c.c DRIVER_i2c.h
  group driver/i2c/HAL_i2c
    ../driver/i2c/HAL_i2c/: HAL_i2c.c HAL_i2c.h
  group driver/keyboard
    ../driver/keyboard/: DRIVER_keyboard.c DRIVER_keyboard.h
  group driver/lcd_1602
    ../driver/lcd_1602/: lcd.c lcd.h
  group driver/port/HAL_port
    ../driver/port/HAL_port/: HAL_port.c HAL_port.h
  group driver/tea5767
    ../driver/tea5767/: tea5767.c tea5767.h
  group source
    ../source/: main.c
  group startup
    ../MKL46Z/: startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
